# Keil uVision project main_STM32L1xx.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32L100RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1 OneElfS=1
  c define: _KEIL, _HSE_BYPASS_ON,  xTERMINAL
  c include: .\src;..\EmbSysLib\Lib\Src
  asm define: Stack_Size=0xC00, Heap_Size=0x0C00
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Src
    ../EmbSysLib/Lib/Src/Hardware/MCU/STM32L1xx/Sys/Keil/: startup_stm32l1xx_mdp.s RTOScontext.s
    ../EmbSysLib/Lib/Src/: lib.cpp
    ./Src/: main.cpp
    ../EmbSysLib/Lib/Src/Module/: RTOS.cpp
